# Keil uVision project NRF.uvprojx, settings and files
target NRF (6160000::V6.16::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: NRF +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\keil;..\..\Lib\CMSIS\CM3\CoreSupport;..\..\Lib\STM32F10x_StdPeriph_Driver\inc;..\..\Project;..\..\Lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group lib
    ../../Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: core_cm3.c startup_stm32f10x_md.s
  group user
    ../: main.c stm32f10x_it.c system_stm32f10x.c
